# Keil uVision project pmsm_foc_driver.uvprojx, settings and files
target pmsm_foc_driver (6210000::V6.21::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: pmsm_foc_driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/F4xx/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../BSP;../CANopen/CANopenNode;../CANopen/CANopenNode_STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c motorcontrol.c speed_torq_ctrl.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mcp_config.c mc_tasks.c mc_tasks_foc.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32f4xx_mc_it.c mc_parameters.c hf_registers.c sync_registers.c mcp.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c trajectory_ctrl.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c mcpa.c
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_2_f4xx_pwm_curr_fdbk.c
  group BSP
    ../BSP/: bsp_can.c
  group CANopenNode
    ../CANopen/CANopenNode/: CANopen.c
    ../CANopen/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ../CANopen/CANopenNode/303/: CO_LEDs.c
    ../CANopen/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ../CANopen/CANopenNode/storage/: CO_storage.c
  group CANopenNode_STM32
    ../CANopen/CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c CIA402.c
software components: CMSIS:CORE 5.6.0
